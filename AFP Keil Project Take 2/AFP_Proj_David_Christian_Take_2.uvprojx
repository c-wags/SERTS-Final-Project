# Keil uVision project AFP_Proj_David_Christian_Take_2.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AFP_Proj_David_Christian_Take_2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000, USE_HAL_DRIVER, STM32F407xx, USE_STM32F4_DISCO, ARM_MATH_CM4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: audio.h cs43l22.c cs43l22.h libPDMFilter_CM4_Keil.lib main.c main.h stm32f4_discovery.c stm32f4_discovery.h stm32f4_discovery_audio.c stm32f4_discovery_audio.h stm32f4xx_it.c stm32f4xx_it.h Thread.h UART_driver.c UART_driver.h Thread2.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0, File System:CORE 6.8.0, File System:Drive:USB 6.8.0, USB:CORE 6.8.0, USB:Host 6.8.0, USB:Host:MSC 6.8.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:USART 2.7, CMSIS Driver:USB Host:Full-speed 2.18, Compiler:I/O:File 1.1.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:I2S 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
